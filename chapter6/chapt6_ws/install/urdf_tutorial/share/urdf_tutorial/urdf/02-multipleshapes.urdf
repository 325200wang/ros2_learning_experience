Commit message: 0

File: chapter6/chapt6_ws/install/urdf_tutorial/share/urdf_tutorial/urdf/02-multipleshapes.urdf (robot description, URDF)
Before this commit: robot multipleshapes, 2 links, 1 joints
Joints:
- joint base_to_right_leg: origin (none) -> xyz=0 0.25 0 rpy=0 0 0
